options:
  parameters:
    generate_options: qt_gui
    id: DVBT_transmit
    output_language: python
    title: DVBT_transmit
  states: {}

blocks:
- name: TXgain
  id: variable
  parameters:
    value: '50'
  states: {state: disabled}
- name: centerFrq
  id: variable
  parameters:
    value: '1550000000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: TXgain
  id: parameter
  parameters:
    type: intx
    value: '50'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.dat
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ./togrc.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '2000000'
    type: complex
  states: {}
- name: cFrq
  id: parameter
  parameters:
    type: intx
    value: '434000000'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: (1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j)
    type: ccc
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '100'
    taps: (1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j)
    type: ccc
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '8000000'
    center_freq0: cFrq
    gain0: TXgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: cFrq
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0_0, '0', fft_filter_xxx_0, '0']
- [blocks_file_source_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_file_source_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', fft_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
